Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: Projektnummer
Time: 2022-08-25T13:26:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220224_1700(x64) - Exporter 19.5.0.0 - Alternative Benutzeroberfläche 19.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 25 13:26:22 2022 * Host: NB-DM-W10 * Database: C:\Users\DMAYNI~1\AppData\Local\Temp\{B49FD73A-D26B-42D1-B862-C0841CC9898F}\ifc * Database version: 5507 * Database creation date: Thu Aug 25 13:26:22 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 25 13:26:22 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 25 13:26:22 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 765625; RefLongitude: 13, 23, 59, 998626; RefElevation: 0 m
Sonstige - Auftraggeber: Bauherr; Kategorie: Projektinformationen; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Sonstige - Kategorie: Projektinformationen; Auftraggeber: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuildingStorey: Ebene:Ebene, Ebene 0
LongName: Ebene 0; Elevation: 0 m
Sonstige(Type) - Kategorie: Ebenen; Familienname: Ebene
ID-Daten(Type) - Typname: Ebene
Pset_AirSideSystemInformation - Name: Ebene 0; sets with these values: 2
Abhängigkeiten - Ansicht: 0 m
Abmessungen - Höhe für Berechnung: 0 m
ID-Daten - Gebäudegeschoss: yes; Name: Ebene 0; Tragwerk: no
Sonstige - Familie: Ebene: Ebene; Familie und Typ: Ebene: Ebene; Kategorie: Ebenen; Typ: Ebene: Ebene; Typ-ID: Ebene: Ebene
Abhängigkeiten(Type) - Basishöhe: Projekt-Basispunkt
Grafiken(Type) - Farbe: 16711680; Linienmuster: Verdeckt; Linienstärke: 1; Symbol: Beschriftung Ebene: Beschriftung Ebene; Symbol bei Ende 1 Standard: no; Symbol bei Ende 2 Standard: yes

# IfcDistributionPort, Port_549084
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: GAZ SARIR:SARIR Q WA, GAZ SARIR:SARIR Q WA:549084
In: Ebene 0
Type - Description: widerstandsfähige Sicherheitsleuchte für den Innen- und Außenbereich; PredefinedType: USERDEFINED; Material: Alu anthrazit (2), Weiss leuchtend
Type - Abmessungen - Breite: 0.24 m; Durchmesser: 0.27 m; Größe des Lichtquellensymbols: 0.02 m; Höhe: 0.24 m; Tiefe: 0.09 m
Type - Elektro - Lampe: LED
Type - Elektro - Lasten - Anschlussleistung bei Allgemeinbeleuchtung: 0 W; Scheinlast: 15 W
Type - Fotometrische Daten - Anfängliche Farbtemperatur: 5000 K; Anfangsfarbe: 0; Anfangsintensität: 0; Beleuchtungsstärke: 8.89971 lx; Farbfilter: 16777215; Farbtemperaturverschiebung bei Dämpfen der Lampe: <Keine Auswahl>; Lichtquellendefinition (Familie): Punkt+Kugelförmig; Lichtstärke: 82.681 cd; Lichtstrom: 1039 lm; Lichtverlustfaktor: 0; Lichtverlustfaktor insgesamt: 1; Wattzahl: 6.99466 W; Wirkungsgrad: 148.542 s3*lm/kg/m2
Type - ID-Daten - Bauelement: Sicherheitsleuchte; Beschreibung: widerstandsfähige Sicherheitsleuchte für den Innen- und Außenbereich; Hersteller: GAZ Notstromsysteme GmbH; Modell: SARIR Q WA; OmniClass-Nummer: 23.80.70.11.21; OmniClass-Titel: Emergency Lighting; Typenkommentare: Wandanbau; Typname: SARIR Q WA; URL: https://gaz.de/
Type - Materialien und Oberflächen - Gehäusefarbe: wahlweise: weiß, schwarz, anthrazit; Werkstoff, Gehäuse Notbeleuchtung: Aluminium-Druckguss
Type - Modelleigenschaften - _Einzelbatterie: no; _Zentralbatterie: yes; Ausbildung Leuchtmittel: LED; Bauteil, Not-/Sicherheitsbeleuchtung: Sicherheitsleuchte; Bemessungsbetriebsdauer h Notlichtstrahler: -; Bemessungsbetriebsspannung V: 230 AC/220 DC (+/- 20%); Betriebsart Notbeleuchtung: Bereitschaftsschaltung; Leuchte Bauweise: im Kompaktgehäuse; Montage Notleuchte: Wandanbau; Produktinformationen: https://gaz.de/g-light/sicherheitsleuchten/; Schutzart: IP65; Schutzklasse elektrische Betriebsmittel: I; Spannung: 230 V; Umgebungstemperatur Grad C: -25 bis +40
Type - Sonstige - Kategorie: Leuchten; Familienname: GAZ SARIR
Type - Vollständige Legende - B_Anschluss Versatz hinten: 0.08 m; B_Anschuss Versatz oben: 0.12 m; B_Bel Versatz hinten: 0.19 m; B_Bel Versatz oben: 0.12 m; B_Durchmesser Halter: 0.1 m; B_Einfüge Versatz von oben: 0 m; B_Einfüge Versatz von vorn: 0.09 m; B_Halter Dicke: -0.02 m; B_Leuchtkörper Dicke: -0.036 m; B_Leuchtkörper Radius: 0.111 m; B_Leuchtkörper RE: 0.185 m; B_MK Form quadr Decke: no; B_MK Form quadr Wand: yes; B_MK Form rund Decke: no; B_MK Form rund M Decke: no; B_MK Form rund M Wand: no; B_MK Form rund Wand: no; B_MK Versatz hinten: 0.02 m; B_MK Versatz links: 0.012 m; B_MK Versatz oben: 0.012 m; B_MK Versatz rechts: 0.012 m; B_MK Versatz unten: 0.012 m; B_MK Versatz vorn: 0.036 m; B_Montage: 5; B_Montage DA: no; B_Montage DA Seil: no; B_Montage DE: no; B_Montage DE Seil: no; B_Montage WA: yes; B_Montage WE: no; B_Sarir Typ: 1
Type - Pset_ManufacturerTypeInformation - Manufacturer: GAZ Notstromsysteme GmbH
Pset_DistributionFlowElementCommon - Reference: SARIR Q WA; sets with these values: 2
Abhängigkeiten - Basisbauteil: Ebene : Ebene 0; Ebene: Ebene: Ebene 0; Montage/-Deckenhöhe: 2.5 m; Versatz: 0 m
Abmessungen - Fläche: 1.1109 m2; Volumen: 0.00412781 m3
Elektro - Beleuchtung - Wirkungsgrad berechnen: no
Elektro - Stromkreise - Elektrische Daten: 230 V/1-15 VA
ID-Daten - Kennzeichen: 53
Phasen - Phase erstellt: Phase 1
Sonstige - Familie: GAZ SARIR: SARIR Q WA; Familie und Typ: GAZ SARIR: SARIR Q WA; Typ: GAZ SARIR: SARIR Q WA; Typ-ID: GAZ SARIR: SARIR Q WA
