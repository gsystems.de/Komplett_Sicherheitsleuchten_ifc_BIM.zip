Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 2018_01
Time: 2026-07-03T08:02:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180216_1515(x64) - Exporter 19.0.0.405 - Alternativ-UI 19.0.0.405
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 03 08:02:42 2026 * Host: DE-PF4RD0WR * Database: C:\Users\DMAYNI~1.NTI\AppData\Local\Temp\{18823100-8E88-46F7-85C5-1A205D98B3E7}\ifc * Database version: 5507 * Database creation date: Fri Jul 03 08:02:42 2026 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jul 03 08:02:42 2026 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 03 08:02:42 2026 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 519 m
Text - Bauherr: AUTODESK; Baustellenort: BAUORT; Baustellenstraße: BAUSTRASSE 1; Einlagezahl: 123-45; Gerichtsbezirk: GERICHTSBEZIRK; Grundstücksnummer: GR; Katastralgemeinde: KG; Kundenadresse: KUNDENSTRASSE 1; Kundenort: KUNDENORT; Kundentelefon: 0000-00000-1; Kundenzusatz: KUNDENZUSATZ
Sonstige - Auftraggeber: Bauherr; Kategorie: Projektinformationen; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektnummer: 2018_01; Projektstatus: Projekt Status; Verfasser eMail: E-Mail; Verfasser Firma 1: AUTODESK GmbH; Verfasser PLZ Ort: Ort; Verfasser Strasse: Adresse; Verfasser Telefon: Telefon; Verfasser URL: www.Autodesk.de/BIM

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Sonstige - Kategorie: Projektinformationen; Auftraggeber: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektnummer: 2018_01; Projektstatus: Projekt Status; Verfasser eMail: E-Mail; Verfasser Firma 1: AUTODESK GmbH; Verfasser PLZ Ort: Ort; Verfasser Strasse: Adresse; Verfasser Telefon: Telefon; Verfasser URL: www.Autodesk.de/BIM
Text - Bauherr: AUTODESK; Baustellenort: BAUORT; Baustellenstraße: BAUSTRASSE 1; Einlagezahl: 123-45; Gerichtsbezirk: GERICHTSBEZIRK; Grundstücksnummer: GR; Katastralgemeinde: KG; Kundenadresse: KUNDENSTRASSE 1; Kundenort: KUNDENORT; Kundentelefon: 0000-00000-1; Kundenzusatz: KUNDENZUSATZ

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 m
Sonstige(Type) - Kategorie: Ebenen; Familienname: Ebene
ID-Daten(Type) - Typname: Ebene
Grafiken(Type) - Farbe: 16728128; Linienmuster: (Ebene); Linienstärke: 1; Symbol: Beschriftung Ebene Oberkante: Allgemein; Symbol bei Ende 1 Standard: no; Symbol bei Ende 2 Standard: yes
Abhängigkeiten(Type) - Basishöhe: Projekt-Basispunkt
Abhängigkeiten - Ansicht: 0 m
Abmessungen - Höhe für Berechnung: 1 m
Daten - FM Geschoss: EG
ID-Daten - Gebäudegeschoss: no; Name: Ebene 0; Tragwerk: no
Sonstige - Familie: Ebene: Ebene; Familie und Typ: Ebene: Ebene; Kategorie: Ebenen; Typ: Ebene: Ebene; Typ-ID: Ebene: Ebene

# IfcFlowTerminal: MIRA Q DE, GSYSTEMS MIRA:MIRA Q DE:2392795
In: Ebene 0
Type - Material: Stahl, beschichtet, Weiss leuchtend
Type - Abmessungen - Breite: 0.08 m; Durchmesser: 0.08 m; Größe des Lichtquellensymbols: 0.02 m; Höhe: 0.01 m; Tiefe: 0.08 m
Type - Elektro - Lampe: LED
Type - Elektro - Lasten - Scheinlast: 7 W
Type - Fotometrische Daten - Anfängliche Farbtemperatur: 5000 K; Anfangsfarbe: 0; Anfangsintensität: 0; Beleuchtungsstärke: 11.5122 lx; Farbfilter: 16777215; Farbtemperaturverschiebung bei Dämpfen der Lampe: <Keine Auswahl>; Lichtquellendefinition (Familie): Punkt+HemiSpherical; Lichtstärke: 106.952 cd; Lichtstrom: 336 lm; Lichtverlustfaktor: 0; Lichtverlustfaktor insgesamt: 1; Wattzahl: 2.26199 W; Wirkungsgrad: 148.542 s3*lm/kg/m2
Type - ID-Daten - Bauelement: Sicherheitsleuchte; Beschreibung: Sicherheitsleuchte als Deckeneinbau-Downlight; Hersteller: GSYSTEMS GmbH; Modell: MIRA DE Q; OmniClass-Nummer: 23.80.70.11.21; OmniClass-Titel: Emergency Lighting; Typenkommentare: Deckeneinbau; Typname: MIRA Q DE; URL: https://gsystems.de/
Type - Materialien und Oberflächen - Gehäusefarbe: weiß RAL 9016; Werkstoff, Gehäuse Notbeleuchtung: Stahl, beschichtet
Type - Modelleigenschaften - _Einzelbatterie: no; _Info Versorgung / Überwachung: -; _Zentralbatterie: yes; Ausbildung Leuchtmittel: LED; Bauteil, Not-/Sicherheitsbeleuchtung: Sicherheitsleuchte; Bemessungsbetriebsdauer h Notlichtstrahler: -; Bemessungsbetriebsspannung V: 230 AC/220 DC (+/- 20%); Betriebsart Notbeleuchtung: Dauer-, Bereitschaftsschaltung; Leuchte Bauweise: im Kompaktgehäuse; Montage Notleuchte: Deckeneinbau; Produktinformationen: https://gsystems.de/Produkte/GLIGHT/Sicherheitsleuchten/; Schutzart: IP20; Schutzklasse elektrische Betriebsmittel: I; Spannung: 230 V; Umgebungstemperatur Grad C: -10 bis +40
Type - Sonstige - Kategorie: Leuchten; Familienname: GSYSTEMS MIRA
Type - Vollständige Legende - B_Abzug Durchmesser: 0.068 m; B_Abzug Versatz Ende: 0.06 m; B_Abzug Versatz Start: 0 m; B_Abzug Winkel: 90 deg; B_Anschl Versatz hinten: 0 m; B_Anschuss Versatz oben: 0 m; B_Bel Versatz hinten: 0.04 m; B_Bel Versatz oben: 0.01 m; B_Einfüge Versatz von oben: 0 m; B_Einfüge Versatz von vorn: 0.04 m; B_Leuchtkörper Decke: yes; B_Leuchtkörper DM: 0.022 m; B_Leuchtkörper Wand: no; B_Mira Typ: 2; B_MK Form quadr: yes; B_MK Form rund Decke: no; B_MK Form rund Wand: no; B_MK Versatz hinten: 0 m; B_MK Versatz links: 0 m; B_MK Versatz oben: 0 m; B_MK Versatz rechts: 0 m; B_MK Versatz unten: 0.008 m; B_MK Versatz vorn: 0 m; B_Montage: 3; B_Montage DA: no; B_Montage DA Seil: no; B_Montage DE: yes; B_Montage DE Seil: no; B_Montage WA: no; B_Montage WE: no
Pset_ManufacturerTypeInformation - Manufacturer: GSYSTEMS GmbH
Pset_DistributionFlowElementCommon - Reference: GSYSTEMS MIRA:MIRA Q DE
Abhängigkeiten - Basisbauteil: Ebene : Ebene 0; Ebene: Ebene: Ebene 0; Montage/-Deckenhöhe: 0 m; Versatz: 0 m
Abmessungen - Fläche: 0.0124633 m2; Volumen: 0.00001487 m3
Elektro - Beleuchtung - Wirkungsgrad berechnen: no
Elektro - Stromkreise - Elektrische Daten: 230 V/1-7 VA
ID-Daten - Kennzeichen: 1
Phasen - Phase erstellt: Phase 1
Sonstige - Familie: GSYSTEMS MIRA: MIRA Q DE; Familie und Typ: GSYSTEMS MIRA: MIRA Q DE; Typ: GSYSTEMS MIRA: MIRA Q DE; Typ-ID: GSYSTEMS MIRA: MIRA Q DE
