Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Projektnummer
Time: 2021-02-24T11:03:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternativ-UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Feb 24 11:03:21 2021 * Host: NB-MAYNICKE-W10 * Database: C:\Users\DMAYNI~1.CAD\AppData\Local\Temp\{73920B82-EE4D-4BD4-9A46-F65BFD596EDD}\ifc * Database version: 5507 * Database creation date: Wed Feb 24 11:03:20 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Feb 24 11:03:21 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Feb 24 11:03:21 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 765625; RefLongitude: 13, 23, 59, 998626; RefElevation: 0 m
Sonstige - Kategorie: Projektinformationen; Kundenname: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Sonstige - Kategorie: Projektinformationen; Kundenname: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 m
Sonstige(Type) - Kategorie: Ebenen; Familienname: Ebene
ID-Daten(Type) - Typname: Ebene
Abhängigkeiten - Ansicht: 0 m
Abmessungen - Höhe für Berechnung: 0 m
ID-Daten - Gebäudegeschoss: yes; Name: Ebene 0; Tragwerk: no
Sonstige - Familie: Ebene: Ebene; Familie und Typ: Ebene: Ebene; Kategorie: Ebenen; Typ: Ebene: Ebene; Typ-ID: Ebene: Ebene
Abhängigkeiten(Type) - Basishöhe: Projekt-Basispunkt
Grafiken(Type) - Farbe: 16711680; Linienmuster: Verdeckt; Linienstärke: 1; Symbol: Beschriftung Ebene: Beschriftung Ebene; Symbol bei Ende 1 Standard: no; Symbol bei Ende 2 Standard: yes

# IfcFlowTerminal: IZAR AO DA, GAZ IZAR:IZAR AO DA:539695
In: Ebene 0
Type - Material: Kunststoff, transparent, Kunststoff, undurchsichtig Weiß
Type - Abmessungen - Breite: 0.37 m; Größe des Lichtquellensymbols: 0.08 m; Höhe: 0.08 m; Tiefe: 0.135 m
Type - Elektro - Lampe: LED
Type - Elektro - Lasten - Scheinlast: 12 W
Type - Fotometrische Daten - Anfängliche Farbtemperatur: 5000 K; Anfangsfarbe: 0; Anfangsintensität: 0; Beleuchtungsstärke: 25.9025 lx; Farbfilter: 16777215; Farbtemperaturverschiebung bei Dämpfen der Lampe: <Keine Auswahl>; Lichtquellendefinition (Familie): Linie+HemiSpherical; Lichtstärke: 240.642 cd; Lichtstrom: 756 lm; Lichtverlustfaktor: 0; Lichtverlustfaktor insgesamt: 1; Von Linienlänge aussenden: 0.08 m; Wattzahl: 5.08947 W; Wirkungsgrad: 148.542 s3*lm/kg/m2
Type - ID-Daten - Bauelement: Sicherheitsleuchte; Beschreibung: strapazierfähige Sicherheitsleuchte für lange Rettungswege; Hersteller: GAZ Notstromsysteme GmbH; Modell: IZAR AO DA; OmniClass-Nummer: 23.80.70.11.21; OmniClass-Titel: Emergency Lighting; Typenkommentare: Deckenanbau; Typname: IZAR AO DA; URL: https://gaz.de/
Type - Materialien und Oberflächen - Gehäusefarbe: Polycarbonat, weiß; Werkstoff, Gehäuse Notbeleuchtung: Kunststoff
Type - Modelleigenschaften - _Einzelbatterie: no; _Zentralbatterie: yes; Ausbildung Leuchtmittel: LED; Bauteil, Not-/Sicherheitsbeleuchtung: Sicherheitsleuchte; Bemessungsbetriebsdauer h Notlichtstrahler: -; Bemessungsbetriebsspannung V: 230 AC/220 DC (+/- 20%); Betriebsart Notbeleuchtung: Bereitschaftsschaltung; Leuchte Bauweise: im Kompaktgehäuse; Montage Sicherheitsleuchte: Deckenanbau; Produktinformationen: https://gaz.de/g-light/sicherheitsleuchten/; Schutzart: IP65; Schutzklasse elektrische Betriebsmittel: II; Spannung: 230 V; Umgebungstemperatur Grad C: -10 bis +40
Type - Sonstige - Kategorie: Leuchten; Familienname: GAZ IZAR
Type - Vollständige Legende - B_Anschuss Versatz oben: 0.02 m; B_AO SO: 1; B_Einfüge Versatz von oben: 0 m; B_Einfüge Versatz von vorn: 0.0675 m; B_Leuchtmittel Versatz oben: 0.08 m; B_Leuchtmittel Versatz vorn: 0.0675 m; B_MK Breite: 0.3 m; B_MK Versatz hinten: 0.004 m; B_MK Versatz oben: 0 m; B_MK Versatz unten: 0.033 m; B_MK Versatz vorn: 0.004 m; B_Montage: 1; B_Montage DA: yes; B_Montage DA Seil: no; B_Montage DE: no; B_Montage DE Seil: no; B_Montage WA: no; B_Montage WE: no
Pset_ManufacturerTypeInformation - Manufacturer: GAZ Notstromsysteme GmbH
Pset_DistributionFlowElementCommon - Reference: IZAR AO DA
Abhängigkeiten - Basisbauteil: Ebene : Ebene 0; Ebene: Ebene: Ebene 0; Montage/-Deckenhöhe: 0 m; Versatz: 0 m
Abmessungen - Fläche: 0.148521 m2; Volumen: 0.00390609 m3
Elektro - Beleuchtung - Wirkungsgrad berechnen: no
Elektro - Stromkreise - Elektrische Daten: 230 V/1-12 VA
ID-Daten - Kennzeichen: 45
Phasen - Phase erstellt: Phase 1
Sonstige - Familie: GAZ IZAR: IZAR AO DA; Familie und Typ: GAZ IZAR: IZAR AO DA; Typ: GAZ IZAR: IZAR AO DA; Typ-ID: GAZ IZAR: IZAR AO DA
