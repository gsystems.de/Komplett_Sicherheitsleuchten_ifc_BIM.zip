Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Projektnummer
Time: 2021-02-24T11:29:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternativ-UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Feb 24 11:29:30 2021 * Host: NB-MAYNICKE-W10 * Database: C:\Users\DMAYNI~1.CAD\AppData\Local\Temp\{1781F8AE-81D7-4593-AE57-137CF182F8F3}\ifc * Database version: 5507 * Database creation date: Wed Feb 24 11:29:29 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Feb 24 11:29:29 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Feb 24 11:29:29 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 765625; RefLongitude: 13, 23, 59, 998626; RefElevation: 0 m
Sonstige - Kategorie: Projektinformationen; Kundenname: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Sonstige - Kategorie: Projektinformationen; Kundenname: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 m
Sonstige(Type) - Kategorie: Ebenen; Familienname: Ebene
ID-Daten(Type) - Typname: Ebene
Abhängigkeiten - Ansicht: 0 m
Abmessungen - Höhe für Berechnung: 0 m
ID-Daten - Gebäudegeschoss: yes; Name: Ebene 0; Tragwerk: no
Sonstige - Familie: Ebene: Ebene; Familie und Typ: Ebene: Ebene; Kategorie: Ebenen; Typ: Ebene: Ebene; Typ-ID: Ebene: Ebene
Abhängigkeiten(Type) - Basishöhe: Projekt-Basispunkt
Grafiken(Type) - Farbe: 16711680; Linienmuster: Verdeckt; Linienstärke: 1; Symbol: Beschriftung Ebene: Beschriftung Ebene; Symbol bei Ende 1 Standard: no; Symbol bei Ende 2 Standard: yes

# IfcFlowTerminal: ATRIA WA, GAZ ATRIA:ATRIA WA:547709
In: Ebene 0
Type - Material: Weiss leuchtend, Stahl weiss, Gruen leuchtend
Type - Abmessungen - Breite: 0.233 m; Größe des Lichtquellensymbols: 0.04 m; Höhe: 0.161 m; Tiefe: 0.136 m
Type - Elektro - Lampe: LED
Type - Elektro - Lasten - Scheinlast: 10 W
Type - Fotometrische Daten - Anfängliche Farbtemperatur: 5000 K; Anfangsfarbe: 0; Anfangsintensität: 0; Beleuchtungsstärke: 9.55926 lx; Farbfilter: 16777215; Farbtemperaturverschiebung bei Dämpfen der Lampe: <Keine Auswahl>; Lichtquellendefinition (Familie): Punkt+HemiSpherical; Lichtstärke: 88.8085 cd; Lichtstrom: 279 lm; Lichtverlustfaktor: 0; Lichtverlustfaktor insgesamt: 1; Wattzahl: 1.87826 W; Wirkungsgrad: 148.542 s3*lm/kg/m2
Type - ID-Daten - Bauelement: Sicherheitsleuchte; Beschreibung: kompakte Wandleuchte zur Ausleuchtung von hervorzuhebenden Stellen gemäß DIN EN 1838 mit hinterleuchtetem Piktogramm; Hersteller: GAZ Notstromsysteme GmbH; Modell: ATRIA WA; OmniClass-Nummer: 23.80.70.11.21; OmniClass-Titel: Emergency Lighting; Typenkommentare: Wandanbau; Typname: ATRIA WA; URL: https://gaz.de/
Type - Materialien und Oberflächen - Gehäusefarbe: weiß RAL 9016; Werkstoff, Gehäuse Notbeleuchtung: Stahl, beschichtet
Type - Modelleigenschaften - _Einzelbatterie: no; _Zentralbatterie: yes; Ausbildung Leuchtmittel: LED; Bauteil, Not-/Sicherheitsbeleuchtung: Sicherheitsleuchte; Bemessungsbetriebsdauer h Notlichtstrahler: -; Bemessungsbetriebsspannung V: 230 AC/220 DC (+/- 20%); Betriebsart Notbeleuchtung: Dauer-, Bereitschaftsschaltung; Leuchte Bauweise: im Kompaktgehäuse; Montage Sicherheitsleuchte: Wandanbau; Produktinformationen: https://gaz.de/g-light/sicherheitsleuchten/; Schutzart: IP40; Schutzklasse elektrische Betriebsmittel: I; Spannung: 230 V; Umgebungstemperatur Grad C: -10 bis +40
Type - Sonstige - Kategorie: Leuchten; Familienname: GAZ ATRIA
Type - Vollständige Legende - B_Anschuss Versatz oben: 0.0805 m; B_Einfüge Versatz von oben: 0 m; B_Einfüge Versatz von vorn: 0.136 m; B_Leuchtmittel Versatz oben: 0.166 m; B_Leuchtmittel Versatz vorn: 0.06 m; B_MK Versatz oben: 0.005 m; B_MK Versatz unten: 0.005 m; B_Montage: 5; B_Montage DA: no; B_Montage DA Seil: no; B_Montage DE: no; B_Montage DE Seil: no; B_Montage WA: yes; B_Montage WE: no
Pset_ManufacturerTypeInformation - Manufacturer: GAZ Notstromsysteme GmbH
Pset_DistributionFlowElementCommon - Reference: ATRIA WA
Abhängigkeiten - Basisbauteil: Ebene : Ebene 0; Ebene: Ebene: Ebene 0; Grundriss Symbol: no; Montage/-Deckenhöhe: 0 m; Piktogramm: 2; Versatz: 0 m
Abmessungen - Fläche: 0.104839 m2; Volumen: 0.00282741 m3
Elektro - Beleuchtung - Wirkungsgrad berechnen: no
Elektro - Stromkreise - Elektrische Daten: 230 V/1-10 VA
ID-Daten - Kennzeichen: 52
Phasen - Phase erstellt: Phase 1
Sonstige - Familie: GAZ ATRIA: ATRIA WA; Familie und Typ: GAZ ATRIA: ATRIA WA; Typ: GAZ ATRIA: ATRIA WA; Typ-ID: GAZ ATRIA: ATRIA WA
Vollständige Legende - B_Pikto Erste Hilfe: yes; B_Pikto Feuerlöscher: no
