Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Projektnummer
Time: 2021-02-24T11:10:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternativ-UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Feb 24 11:10:17 2021 * Host: NB-MAYNICKE-W10 * Database: C:\Users\DMAYNI~1.CAD\AppData\Local\Temp\{7D8512B1-F060-4F1F-921A-28FB65E6E62D}\ifc * Database version: 5507 * Database creation date: Wed Feb 24 11:10:16 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Feb 24 11:10:17 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Feb 24 11:10:17 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 765625; RefLongitude: 13, 23, 59, 998626; RefElevation: 0 m
Sonstige - Kategorie: Projektinformationen; Kundenname: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Sonstige - Kategorie: Projektinformationen; Kundenname: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 m
Sonstige(Type) - Kategorie: Ebenen; Familienname: Ebene
ID-Daten(Type) - Typname: Ebene
Abhängigkeiten - Ansicht: 0 m
Abmessungen - Höhe für Berechnung: 0 m
ID-Daten - Gebäudegeschoss: yes; Name: Ebene 0; Tragwerk: no
Sonstige - Familie: Ebene: Ebene; Familie und Typ: Ebene: Ebene; Kategorie: Ebenen; Typ: Ebene: Ebene; Typ-ID: Ebene: Ebene
Abhängigkeiten(Type) - Basishöhe: Projekt-Basispunkt
Grafiken(Type) - Farbe: 16711680; Linienmuster: Verdeckt; Linienstärke: 1; Symbol: Beschriftung Ebene: Beschriftung Ebene; Symbol bei Ende 1 Standard: no; Symbol bei Ende 2 Standard: yes

# IfcFlowTerminal: SIRIUS Q DA, GAZ SIRIUS:SIRIUS Q DA:542782
In: Ebene 0
Type - Material: Kunststoff, undurchsichtig Weiß, Weiss leuchtend
Type - Abmessungen - Breite: 0.122 m; Durchmesser: 0.129 m; Größe des Lichtquellensymbols: 0.02 m; Höhe: 0.049 m; Tiefe: 0.122 m
Type - Elektro - Lampe: LED
Type - Elektro - Lasten - Scheinlast: 7 W
Type - Fotometrische Daten - Anfängliche Farbtemperatur: 5000 K; Anfangsfarbe: 0; Anfangsintensität: 0; Beleuchtungsstärke: 11.5122 lx; Farbfilter: 16777215; Farbtemperaturverschiebung bei Dämpfen der Lampe: <Keine Auswahl>; Lichtquellendefinition (Familie): Punkt+HemiSpherical; Lichtstärke: 106.952 cd; Lichtstrom: 336 lm; Lichtverlustfaktor: 0; Lichtverlustfaktor insgesamt: 1; Wattzahl: 2.26199 W; Wirkungsgrad: 148.542 s3*lm/kg/m2
Type - ID-Daten - Bauelement: Sicherheitsleuchte; Beschreibung: formschönes quadratisches Downlight für den Deckenaufbau; Hersteller: GAZ Notstromsysteme GmbH; Modell: SIRIUS DA Q; OmniClass-Nummer: 23.80.70.11.21; OmniClass-Titel: Emergency Lighting; Typenkommentare: Deckenanbau; Typname: SIRIUS Q DA; URL: https://gaz.de/
Type - Materialien und Oberflächen - Gehäusefarbe: Polycarbonat, weiß; Werkstoff, Gehäuse Notbeleuchtung: Kunststoff
Type - Modelleigenschaften - _Einzelbatterie: no; _Info Versorgung / Überwachung: -; _Zentralbatterie: yes; Ausbildung Leuchtmittel: LED; Bauteil, Not-/Sicherheitsbeleuchtung: Sicherheitsleuchte; Bemessungsbetriebsdauer h Notlichtstrahler: -; Bemessungsbetriebsspannung V: 230 AC/220 DC (+/- 20%); Betriebsart Notbeleuchtung: Bereitschaftsschaltung; Leuchte Bauweise: im Kompaktgehäuse; Montage Notleuchte: Deckenanbau; Produktinformationen: https://gaz.de/g-light/sicherheitsleuchten/; Schutzart: IP41; Schutzklasse elektrische Betriebsmittel: I; Spannung: 230 V; Umgebungstemperatur Grad C: -10 bis +40
Type - Sonstige - Kategorie: Leuchten; Familienname: GAZ SIRIUS
Type - Vollständige Legende - B_Abzug Durchmesser: 0.022 m; B_Abzug Versatz Ende: -0.029 m; B_Abzug Versatz Start: -0.024 m; B_Abzug Winkel: 90 deg; B_Anschl Versatz hinten: 0 m; B_Anschuss Versatz oben: 0.02 m; B_Bel Versatz hinten: 0.061 m; B_Bel Versatz oben: 0.05 m; B_Einfüge Versatz von oben: 0 m; B_Einfüge Versatz von vorn: 0.061 m; B_Leuchtkörper Decke: yes; B_Leuchtkörper DM: 0.022 m; B_Leuchtkörper Wand: no; B_MK Form quadr: yes; B_MK Form rund Decke: no; B_MK Form rund Wand: no; B_MK Versatz hinten: 0 m; B_MK Versatz links: 0 m; B_MK Versatz oben: 0 m; B_MK Versatz rechts: 0 m; B_MK Versatz unten: 0.005 m; B_MK Versatz vorn: 0 m; B_Montage: 1; B_Montage DA: yes; B_Montage DA Seil: no; B_Montage DE: no; B_Montage DE Seil: no; B_Montage WA: no; B_Montage WE: no; B_Sirius Typ: 1
Pset_ManufacturerTypeInformation - Manufacturer: GAZ Notstromsysteme GmbH
Pset_DistributionFlowElementCommon - Reference: SIRIUS Q DA
Abhängigkeiten - Basisbauteil: Ebene : Ebene 0; Ebene: Ebene: Ebene 0; Montage/-Deckenhöhe: 0 m; Versatz: 0 m
Abmessungen - Fläche: 0.04807 m2; Volumen: 0.000656966 m3
Elektro - Beleuchtung - Wirkungsgrad berechnen: no
Elektro - Stromkreise - Elektrische Daten: 230 V/1-7 VA
ID-Daten - Kennzeichen: 48
Phasen - Phase erstellt: Phase 1
Sonstige - Familie: GAZ SIRIUS: SIRIUS Q DA; Familie und Typ: GAZ SIRIUS: SIRIUS Q DA; Typ: GAZ SIRIUS: SIRIUS Q DA; Typ-ID: GAZ SIRIUS: SIRIUS Q DA
